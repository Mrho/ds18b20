# Keil uVision project ds18b20.uvproj, settings and files
target ds18b20 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: ds18b20 +hex
  c flags: Optimize=8 SizeSpeed=1
  group src
    ./: main.c
